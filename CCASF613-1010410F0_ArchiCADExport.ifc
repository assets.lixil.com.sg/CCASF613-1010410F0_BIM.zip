Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T09:56:28
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort
FlowDirection: SOURCE
Pset_DistributionPortPipe - PortNumber: 1; ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 40 mm; ConnectorDiameter: 40 mm; NominalWidth: 40 mm; NominalHeight: 40 mm

# IfcEnergyConversionDevice: Concept Square 450mm Thin Vessel with Deck, CCASF613-1010410F0:Concept Square 450mm Thin Vessel with Deck:3566
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Concept Square 450mm Thin Vessel with Deck; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Concept Square 450mm Thin Vessel with Deck
Constraints - Elevation: 0 mm
Dimensions - Area: 0.397168 m2; Volume: 0.0411515 m3
Identity Data - Mark: 1
Mechanical - System Classification: Sanitary
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: CCASF613-1010410F0: Concept Square 450mm Thin Vessel with Deck; Family and Type: CCASF613-1010410F0: Concept Square 450mm Thin Vessel with Deck; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: CCASF613-1010410F0: Concept Square 450mm Thin Vessel with Deck; Type Id: CCASF613-1010410F0: Concept Square 450mm Thin Vessel with Deck; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: Vessel; ProductCategory: Fixtures & Vanities (10); ProductGroup: WB Vessel (01); ProductWeight: 15.5 kg; StyleSegment: Modern; SubCategory: Chinaware/Ceramics (WB) (12)
Identity Data(Type) - Assembly Code: D2010400; Description: Concept Square 450mm Thin Vessel with Deck; Keynote: N13; Manufacturer: American Standard; Model: Concept Square 450mm Thin Vessel with Deck; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: CCASF613-1010410F0; Type Name: Concept Square 450mm Thin Vessel with Deck; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ccasf613-1010410f0/document/object-user-guide; BIMObjectName: AmericanStandard_WBVessel_Concept_(CCASF613-1010410F0); NBSDescription: Counter top wash basins; NBSNote: n/a; NBSObjectName: American Standard - Counter top wash basins; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/360
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_96_18; CodePerformance: n/a; Color: White Heat II; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ccasf613-1010410f0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ccasf613-1010410f0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ccasf613-1010410f0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ccasf613-1010410f0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ccasf613-1010410f0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: CCASF613-1010410F0; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: Fine Fire Clay; ModelNumber: CCASF613-1010410F0; ModelReference: Concept Square 450mm Thin Vessel with Deck; ProductionYear: 2021; ReferencedStandard: GB/T 6952-2015; ReplacementCost: n/a; Shape: n/a; Size: L499 x W449 x H181 mm; TypeName: Concept Square 450mm Thin Vessel with Deck; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
